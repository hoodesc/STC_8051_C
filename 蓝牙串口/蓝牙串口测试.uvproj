# Keil uVision project 蓝牙串口测试.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: 蓝牙串口测试 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 蓝牙串口测试.c
