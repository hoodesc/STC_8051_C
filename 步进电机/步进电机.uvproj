# Keil uVision project 步进电机.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 步进电机 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\sorce code
  group Source Group 1
    ./sorce code/: main.c
