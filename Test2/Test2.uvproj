# Keil uVision project Test2.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Test2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Test2;.\Include;.\source code
  group 源组 1
    ./source code/: Test2.c
