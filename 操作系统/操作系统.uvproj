# Keil uVision project 操作系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: 操作系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Source Code
  group Source Group 1
    ./Source Code/: main.c Conf_tny.A51
