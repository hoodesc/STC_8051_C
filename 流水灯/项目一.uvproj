# Keil uVision project 项目一.uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C55 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x4FFF) CLOCK(24000000)
  output: 项目一 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 项目一.c
