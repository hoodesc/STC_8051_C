# Keil uVision project system.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: system +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;..\系统;.\source code
  group Source Group 1
    ./source code/: main.c Delay.c DS1302.c UART.c LCD12864.c NRF24L01_RX.c init.c A6.c
