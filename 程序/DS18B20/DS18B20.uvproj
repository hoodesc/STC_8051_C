# Keil uVision project DS18B20.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DS18B20 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include
  group Source Group 1
    ./source/: main.c Delay.c NRF24L01_TX.c UART.c DS18B20.c
