# Keil uVision project Fan_IR.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104E STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: Fan_IR +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\source code
  group Source Group 1
    ./source code/: main.c Delay.c keyscan.c
