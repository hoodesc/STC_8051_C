# Keil uVision project smg.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C51 Atmel Wireless & uC
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(44000000)
  output: smg
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: smg.c
