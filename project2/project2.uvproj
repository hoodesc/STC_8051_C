# Keil uVision project project2.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: project2 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\project2;.\source code;.\include
  group Project
    ./: main.c
    ./source code/: Delay.c DS18B20.c DS1302.c GSM-GTM900b.c LCD12864.c MQ-2.c Dispaly.c
