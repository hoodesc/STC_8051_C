# Keil uVision project 433Mhz.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W104 STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: 433Mhz +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\include;.\source code
  group Source Group 1
    ./source code/: Delay.c main.c
