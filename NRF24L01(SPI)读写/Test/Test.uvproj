# Keil uVision project Test.uvproj, settings and files
target 目标 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Test +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Test;.\Include;.\source code
  group 源组 1
    ./source code/: Delay.c Test.c NRF24L01_TX.c
