# Keil uVision project NRF24L01_RX.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C2052AD STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: NRF24L01_RX +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\NRF24L01_RX;.\source code;.\Include
  group Source Group 1
    ./source code/: main.c NRF24L01_RX.c Delay.c keyscan.c
